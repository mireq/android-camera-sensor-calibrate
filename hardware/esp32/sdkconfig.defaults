## hardware/esp32/sdkconfig.defaults
```kconfig
CONFIG_IDF_CMAKE=y
CONFIG_APP_BUILD_TYPE_ELF_RAM=y
CONFIG_ESP32_DEFAULT_CPU_FREQ_240=y
CONFIG_ESP32_DEFAULT_CPU_FREQ_MHZ=240
```
